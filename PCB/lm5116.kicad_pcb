# Repository xiaokaizip/lm5116-digital-power

File README.md:

### lm5116数控可调电源

- 输入电压：24V的学生电源

- 目标输出电压：5V-12V
- 目标输出电流：（越大越好）
- 使用0.96寸oled屏显示电压值

### 电路

#### 一、控制器件

- 主要的电压控制器件还是lm5116
- 其中的stm32f103c8t6还是起到辅助的作用。
  - 控制数字电位器的电阻大小
  - 采集电压
  - 接收按键的输入
  - 控制屏幕的显示内容

#### 二、输出电压的调节

- 使用数字电位器调节反馈端的电压，一次来改变输出电压的大小。

#### 三、数据采集

- 使用ADC将电压采集到单片机。
- 再实时数据通过串口传到电脑

#### 四、控制

- 使用按键进行操作。

#### 五、辅助电源

- 使用TD1469将24V的输入降至5V，在使用HX9193将5V的电压降至3.3V个stm32 、数字电位器供电、屏幕供电。

### 代码

#### 一、数字电位器（MCP41100）

- 数字电位器的配置如图所示：

没有用到DMA或是中断，需要的话后续再来给他加上。

- 使能数字电位器

  ~~~c
  #define MCP41100_ENABLE     0B00010011
  #define MCP41100_DISABLE    0B00100000
  ~~~

- 调节数字电位器

  - 数字电位器将100k$\Omega$的电阻分成256份，在使用时，只需将其换算即可。

- 代码

~~~c
uint8_t command;
uint8_t data;

void MCP41100_Send_Data(uint8_t commands, uint8_t datas) {
    HAL_GPIO_WritePin(GPIOA, GPIO_PIN_4, GPIO_PIN_RESET);//来低数字电位器的CS引脚，开始准备通讯
    HAL_Delay(0);
    HAL_SPI_Transmit(&hspi1, &command, 1, 0xffff);//传送命令字节
    HAL_SPI_Transmit(&hspi1, &data, 1, 0xffff);//传送数据字节
    HAL_Delay(0);
    HAL_GPIO_WritePin(GPIOA, GPIO_PIN_4, GPIO_PIN_SET);//将CS引脚拉高，关闭通讯
}

~~~

==相应的文件以放在divice-library文件夹中==

#### 二、延时函数

==相应的文件以放在divice-library文件夹中==

#### 三、OLED屏

- 在此次的项目中，使用了软件iic。

- 其中OLED屏的驱动也是从别处搬来的，后续咋来研究是怎么写的。

- 相关的函数说明

~~~c
 OLED_Init();	//初始化OLED
 OLED_Fill(0x00);//清屏
 OLED_ShowStr(0, 0, "hell world");//在指定位置显示字符串
 OLED_ShowFloat(0,0,123.456f);//在指定的位置显示浮点数（小数点后三位）
~~~

==相应的文件以放在divice-library文件夹中==

#### 四、 数据类型转化

- 将浮点数转化为字符串

~~~c

void numTostring(float num, char str[10]) {

    char ch[10];
    int i = 0;//跟随ch
    int j = 0;//跟随str
    //判断是否是负数
    if (num < 0) {
        num = -num;
        str[j++] = '-';

    }
    //判断是否是小数，如果是小数，先加上0；
    if (num < 1) {
        str[j++] = '0';

    }
    //将小数乘上1000，意味着将该数字精确到小数点后三位，要改精度就改一下1000这个数字就行
    num *= 1000;
    int nums = (int) num;//将小数转换为整数
    for (i = 8; i >= 0; i--) {
        if (i == 5) {
            ch[i] = '.';
            i--;
        }
        ch[i] = nums % 10 + '0';
        nums /= 10;
    }
    //加上小数点
    ch[9] = '\0';
    i = 0;
    while (ch[i] == '0') {
        i++;
    }
    for (i; i <= 9; i++) {
        str[j] = ch[i];
        j++;
    }
}
~~~

==相应的文件以放在divice-library文件夹中==

- 该转换方式还是有点过于复杂，后续还需学习更加方便的转换方法。

#### 五、ADC电压采样

- ADC的简单配置如下：
  - **Data Alignment**：选则有对齐
  - **Scan Conversion Mode：**此项选择扫描模式使能，代表15路ADC输入分别扫描，如果不使能，其只会读取一个输入的值。
  - **Contionous Conversion Mode:**此项选择连续扫描模式，表示将连续不断的对ADC的值进行转换，如果此项不使能，将会只采集一次就停止，直到下一次使能才继续进行一次AD转换。
  - **DisContionous Conversion Mode:**此项与第三项重复。
  - **Number of Conversion：**此处有多少路输出就选择多少。
  - **Rank：**采样时间。
- DMA的配置

- 代码

~~~c
HAL_ADC_Start_DMA(&hadc1, (uint32_t *) adc_value, 1);
//使能DMA，adc_value 为存储数据的数组，1为每一次采样的次数（该数组的大小）
~~~

~~~c
HAL_ADC_Stop_DMA(&hadc1);//失能DMA
~~~

- ADC采样时，如果想要同时采集多个电压，需要打开中断，然后再ADC中断函数中处理数据。

~~~c
void HAL_ADC_ConvCpltCallback();
~~~

可在此函数中，对采集到的电压进行数据处理。

~~~c
void HAL_ADC_ConvCpltCallback(ADC_HandleTypeDef *hadc) {
    uint32_t sum = 0;
    for (uint8_t i = 0; i < 40; i++) {
        sum += adc_value[i];
    }
    avgerage_voltage = (float) sum / 40.0f;
    avgerage_voltage = avgerage_voltage * 0.2f + last_voltage * 0.8f;
    last_voltage = avgerage_voltage;
    flag = 1;
}
~~~

#### 六、按键处理

- 消抖

~~~c
if (HAL_GPIO_ReadPin(GPIOB, GPIO_PIN_12) == GPIO_PIN_RESET) {
        HAL_Delay(10);
        while (HAL_GPIO_ReadPin(GPIOB, GPIO_PIN_12) == GPIO_PIN_RESET);
        HAL_Delay(10);
        flag = RESISTANCE_UP;
    } 
~~~

### 问题

- 该板子是一个可调压的buck电路，输入电压为24V，输出电压为5V至12V
- 可通过stm32f103c6t6，控制数字电位器，以此来控制输出电压。

- 该板子函数有一点问题
 - 按键的设置没设置好。
 - 比如lm5116发烫有点严重，可能是参数还没调好。
 - 采样的滤波还没写好。
 - ……

## KiCad design PCB/lm5116.kicad_pcb

Parts:
C1: 4.7uf; C_1210_3225Metric
C2, C14: 100nf; C_1210_3225Metric
C3: 220pf; C0603(1608M)
C4: 33nf; C0603(1608M)
C5: 6.8pf; C0603(1608M)
C6: 82pf; C0603(1608M)
C7: 100nf; C0603(1608M)
C8: 1uf; C0603(1608M)
C9, C11, C12, C13: 47uf; C_1210_3225Metric
C10: 0.1uf; C_1210_3225Metric
C15, C16, C17, C18, C19, C20, C21, C22, C23, C26, C29, C31, C32: 100n; C0603(1608M)
C24, C27: 2.2u; C0603(1608M)
C25: C; C0603(1608M)
C28, C30: 2.2u; C1206(3216M)
C33: C_Polarized; CP_Elec_6.3x7.7
D1: B340; D_SMA
D2, D4, D5, D7: LED; LED0603(1608M)
D3, D6: Diode_LED; LED0603(1608M)
J1: Conn_01x02_Female; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J2: Conn_01x02_Female; AMASS_XT30U-F_1x02_P5.0mm_Vertical
J3: Conn_01x04; GH1.25_V_4
J4: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J6: Conn_01x04_Male; PinSocket_1x04_P2.54mm_Vertical
L1: 3.3uh; L_Wuerth_HCI-1040
L2: 22uh; L_Abracon_ASPI-0630LR
Q1, Q2: CSD18540Q5B; TDSON-8-1
R1: 28k; R_0603_1608Metric
R2: 1.91k; R_0603_1608Metric
R3: 5.23k; R_0603_1608Metric
R4: 1M; R_0603_1608Metric
R5: 221k; R_0603_1608Metric
R6: 5m; R_2512_6332Metric
R7, R9: 10k; R_0603_1608Metric
R8: 3.24K; R_0603_1608Metric
R10, R11, R12, R13, R14, R15, R21, R26: 1K; R0603(1608M)
R16, R22: 10k; R0603(1608M)
R17: 1M; R0603(1608M)
R18: R; R0603(1608M)
R19: 8.3k; R0603(1608M)
R20: 43k; R0603(1608M)
R23, R24, R25: 3.24K; R0603(1608M)
SW1, SW2, SW3, SW4, SW5: SW_Push; SW_SPST_FSMSM
U1: LM5116MH
U2: STM32F103C6Tx; LQFP-48_7x7mm_P0.5mm
U3: CH340E; MSOP-10_3x3mm_P0.5mm
U4: TD1469; SOT-23-6
U5: MCP41100; SOIC-8_3.9x4.9mm_P1.27mm
U6: HX9193; SOT-23-5_HandSoldering

Connections:
+5V: C26.1, C28.1, C30.1, L2.2, R20.1, R22.2, U6.1 (VIN), U6.3 (EN)
/A: U5.5 (PA0)
/B: R8.2, R23.1, U5.7 (PB0)
/COMP: C5.1, R5.1, U1.9 (COMP)
/DN: J4.A7 (D-), J4.B7 (D-), U3.2 (UD-)
/DP: J4.A6 (D+), J4.B6 (D+), U3.1 (UD+)
/FB: C5.2, C6.2, R7.2, R8.1, U1.8 (FB), U5.6 (PW0)
/HB: C7.2, D1.1 (K), U1.18 (HB)
/HO: Q1.4 (G), U1.19 (HO)
/LO: Q2.4 (G), U1.15 (LO)
/SW: C7.1, L1.1, Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.5 (D), U1.20 (SW)
/VIN: C1.1, C2.1, C14.1, C24.1, J1.2, Q1.5 (D), R1.1, R4.1, R16.2, R17.2, U1.1 (VIN), U4.5 (VIN)
/VOUT: C9.2, C10.2, C11.2, C12.2, C13.2, C33.1, J2.2, L1.2, R7.1, R24.1, R26.1, U1.10 (VOUT)
ADC1: R24.2, R25.1, U2.10 (PA0)
ADC2: U2.11 (PA1)
ADC3: U2.12 (PA2)
ADC4: U2.13 (PA3)
CLK: J3.3, U2.37 (PA14)
DIO: J3.2, U2.34 (PA13)
GND: C1.2, C2.2, C3.2, C4.2, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.2, C15.1, C16.1, C17.1, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C28.2, C29.2, C30.2, C31.1, C32.1, C33.2, D3.1 (Cathode), D4.1 (K), D5.1 (K), D6.1 (Cathode), D7.1 (K), J1.1, J2.1, J3.4, J4.A1 (GND), J4.A12 (GND), J4.B1 (GND), J4.B12 (GND), J4.S1 (SHIELD), J6.1, R2.2, R3.2, R6.2, R10.2, R19.2, R23.2, R25.2, SW1.1, SW2.2, SW3.2, SW4.2, SW5.2, U1.6 (AGND), U1.11 (DEMB), U1.13 (CSG), U1.14 (PGND), U1.17 (VCCX), U1.21 (DAP), U2.8 (VSSA), U2.23 (VSS), U2.35 (VSS), U2.47 (VSS), U3.3 (GND), U4.2 (GND), U5.4 (VSS), U6.2 (GND); also elsewhere on the board
MISO: U2.16 (PA6)
MOSI: U2.17 (PA7), U5.3 (SI)
NRST: C16.2, R9.2, SW1.2, U2.7 (NRST); also elsewhere on the board
unnamed: C3.1, U1.5 (RAMP)
unnamed: C4.1, U1.7 (SS)
unnamed: C6.1, R5.2
unnamed: C8.2, D1.2 (A), U1.16 (VCC)
unnamed: C27.1, L2.1, U4.6 (SW)
unnamed: C27.2, U4.1 (BST)
unnamed: D2.2 (A), R11.2
unnamed: D3.2 (Anode), R16.1
unnamed: D4.2 (A), R18.2
unnamed: D5.2 (A), R21.2
unnamed: D6.2 (Anode), R22.1
unnamed: D7.2 (A), R26.2
unnamed: Q2.1 (S), Q2.2 (S), Q2.3 (S), R6.1, U1.12 (CS)
unnamed: R1.2, R2.1, U1.2 (UVLO)
unnamed: R3.1, U1.3 (RT/SYNC)
unnamed: R4.2, U1.4 (EN)
unnamed: R10.1, U2.44 (BOOT0)
unnamed: R17.1, U4.4 (EN)
unnamed: R19.1, R20.2, U4.3 (FB)
PA8: D2.1 (K)
PB12/K1: C15.2, R12.2, SW2.1, U2.25 (PB12); also elsewhere on the board
PB13/K2: C17.2, R13.2, SW3.1, U2.26 (PB13); also elsewhere on the board
PB14/K3: C31.2, R14.2, SW4.1, U2.27 (PB14); also elsewhere on the board
PB15/K4: C32.2, R15.2, SW5.1, U2.28 (PB15); also elsewhere on the board
RCC_OSC_IN: U2.5 (PD0)
RCC_OSC_OUT: U2.6 (PD1)
RX: U2.43 (PB7), U3.8 (TXD)
SCK: U2.15 (PA5), U5.2 (SCK)
TX: U2.42 (PB6), U3.9 (RXD)
VCC: C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C25.1, C29.1, J3.1, J6.2, R9.1, R11.1, R12.1, R13.1, R14.1, R15.1, R18.1, R21.1, U2.1 (VBAT), U2.9 (VDDA), U2.24 (VDD), U2.36 (VDD), U2.48 (VDD), U3.7 (VCC), U3.10 (V3), U5.8 (VDD), U6.5 (VOUT)
i2C1_SCL: J6.3, U2.45 (PB8)
i2C1_SDA: J6.4, U2.46 (PB9)
~CS: U2.14 (PA4), U5.1 (~CS)

Notes on the sheet:
LDO
数字电位器
KEY
MCU
lm5116
OLED屏接口
辅助电源
USB2UART

Board: 2 copper layers, 56.3 x 62.4 mm, 86 parts (15 on the bottom side), 48 nets.

Other parts of the board:
K1, K2, K3, K4: SW_Push; SW_SPST_FSMSM
SW: SW_Push; SW_SPST_FSMSM

Their connections:
GND: K1.2, K2.2, K3.2, K4.2, SW.1; also elsewhere on the board
NRST: SW.2; also elsewhere on the board
PB12/K1: K1.1; also elsewhere on the board
PB13/K2: K2.1; also elsewhere on the board
PB14/K3: K3.1; also elsewhere on the board
PB15/K4: K4.1; also elsewhere on the board

## Code that names these connections

File c6t6-lm5116/c6t6-lm5116.ioc (part):

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Mcu.Name=STM32F103C(4-6)Tx
Mcu.Package=LQFP48
Mcu.UserName=STM32F103C6Tx
PA0-WKUP.Signal=ADCx_IN0
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=CS
PA4.Signal=GPIO_Output
PA5.Mode=Full_Duplex_Master
PA5.Signal=SPI1_SCK
PA6.Mode=Full_Duplex_Master
PA6.Signal=SPI1_MISO
PA7.Mode=Full_Duplex_Master
PA7.Signal=SPI1_MOSI
PA8.GPIOParameters=GPIO_Label
PA8.GPIO_Label=LED
PA8.Signal=GPIO_Output
PB12.GPIOParameters=GPIO_Label
PB12.GPIO_Label=K1
PB12.Signal=GPIO_Input
PB13.GPIOParameters=GPIO_Label
PB13.GPIO_Label=K2
PB13.Signal=GPIO_Input
PB14.GPIOParameters=GPIO_Label
PB14.GPIO_Label=K3
PB14.Signal=GPIO_Input
PB15.GPIOParameters=GPIO_Label
PB15.GPIO_Label=K4
PB15.Signal=GPIO_Input
PB6.Mode=Asynchronous
PB6.Signal=USART1_TX
PB7.Mode=Asynchronous
PB7.Signal=USART1_RX
PB8.GPIOParameters=GPIO_Label
PB8.GPIO_Label=SCL
PB8.Signal=GPIO_Output
PB9.GPIOParameters=GPIO_Label
PB9.GPIO_Label=SDA
PB9.Signal=GPIO_Output
PD0-OSC_IN.Mode=HSE-External-Oscillator
PD0-OSC_IN.Signal=RCC_OSC_IN
PD1-OSC_OUT.Mode=HSE-External-Oscillator
PD1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=12000000
RCC.SYSCLKFreq_VALUE=64000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2022-10-16 Finsh the initial configuration
2022-10-16 fix some error of README.md

Notices in the files:
parts and their libraries:
Copyright 2021 Accelerated Designs. All rights reserved.
